# Keil uVision project mspi_quad_example.uvprojx, settings and files
target mspi_quad_example (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: mspi_quad_example
  AfterMake: fromelf --bin --output bin\mspi_quad_example.bin bin\mspi_quad_example.axf
  AfterMake: fromelf -cedrst --output bin\mspi_quad_example.txt bin\mspi_quad_example.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_UTIL_FAULTISR_PRINT AM_PART_APOLLO3 GIGA_5F1GQ4RB91G AM_PACKAGE_BGA keil
  c include: ../../../../../CMSIS/AmbiqMicro/Include;../src;../../../../../mcu/apollo3;../../../../../CMSIS/ARM/Include;../../../../../utils;../../../../../devices;../../../../..;../../../bsp
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\mspi_quad_example.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: mspi_quad_example.c
  group devices
    ../../../../../devices/: am_devices_fireball.c am_devices_mspi_flash.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ./: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
